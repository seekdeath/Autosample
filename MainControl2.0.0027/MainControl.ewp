# IAR project MainControl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103R8 ST STM32F103R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $PROJ_DIR$; main; ADC; QUEUE; RS485; bsp; uCOS-II; uCOS-II\Source; uCOS-CPU; uCOS_LIB; cpu\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 主控板2.0.0027.bin
  ILINK.IlinkOutputFile: MainControl.out
  ILINK.IlinkIcfFile: settings\STM32_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Agreement
    ./: Agreement.c Agreement.h
  group BSP
    BSP/: bsp.c bsp.h bsp_int.c
  group Device/GPIO
    ./: gpio.c gpio.h
  group Device/I2C
    ./: I2C.c I2C.h
  group Device/Motor
    ./: microswitch.c microswitch.h MotionErr.c MotionErr.h Motor.c Motor.h MotorAddSam.c MotorAddSam.h MotorMoveSam.c MotorMoveSam.h MotorRotate.c MotorRotate.h MotorSubSam.c MotorSubSam.h MotorTrasmition.c Motortrasmition.h
  group Device/TIM
    ./: tim.c tim.h
  group Device/UART
    ./: uart.c uart.h
  group Fwlib/inc
    cpu/inc/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Fwlib/src
    cpu/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group Main
    main/: app_cfg.h app_vect_v5.c GlobalVar.h includes.h MainStart.c os_cfg.h stm32f10x_conf.h
  group ucos-cpu
    uCOS-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_def.h
  group ucos-II
    uCOS-II/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group ucos-II/Source
    uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group ucos-lib
    uCOS_LIB/: lib_def.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
